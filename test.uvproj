# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F8363B SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF)  XRAM(0-0x2FF) CLOCK(24000000)
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c S_TouchKeyCFG.C SC92F8X6XB_HighSensitive_Lib_T1_V1.2.0.LIB
